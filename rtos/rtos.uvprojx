# Keil uVision project rtos.uvprojx, settings and files
target STM32F0 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Kernel
    ./: rtos.c rt_HAL.c
  group User
    ./: main.c
  group CMSIS_Device
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
target TM4C123G (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TM4C123GH6PM
  c include: .;.\CMSIS\Include;.\CMSIS\Device\TI\TM4C123G\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
